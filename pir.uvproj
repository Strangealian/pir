# Keil uVision project pir.uvproj, settings and files
target 目标 1 (MCS-51)
  device: SST89x516RD2 SST
  cpu: IRAM(0-0xFF) XRAM(0-0x2FF) IROM(0-0xFFFF) CLOCK(40000000)
  output: pir
  c flags: Optimize=8 SizeSpeed=1
  group 源组 1
    ./: pirtest.asm
